# Keil uVision project APP_LED.uvprojx, settings and files
target 407_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_LED4_TOGGLE_407
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0,SYSCLK_FREQ_200MHz
  c include: ..\SYSTEM;..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\APP_LED4_TOGGLE
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_gpio_ex.c misc.c
  group SYSTEM
    ../SYSTEM/: led.c usart.c
