# Keil uVision project IAP_ETH.uvprojx, settings and files
target IAP_ETH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IAP_ETH
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0
  c include: ..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\AT32F407_IAP_ETH;..\Utilities\lwip-2.1.2\port;..\Utilities\lwip-2.1.2\port\arch;..\Utilities\lwip-2.1.2\src\include;..\Utilities\lwip-2.1.2\src\include\lwip;..\SYSTEM;..\..\..\..\..\Project\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c netconf.c at32f4xx_it.c eth_config.c tftpserver.c httpserver.c
  group BSP
    ../../../../../Project/AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_dma.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group LwIP
    ../Utilities/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Utilities/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Utilities/lwip-2.1.2/src/netif/: ethernet.c
    ../Utilities/lwip-2.1.2/port/: ethernetif.c sys_arch.c
  group SYSTEM
    ../SYSTEM/: flash.c sys.c iap.c
  group README
    ../: readme.txt
