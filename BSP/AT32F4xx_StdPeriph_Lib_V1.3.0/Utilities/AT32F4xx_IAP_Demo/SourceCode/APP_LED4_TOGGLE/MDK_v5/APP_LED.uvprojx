# Keil uVision project APP_LED.uvprojx, settings and files
target 403_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_LED4_TOGGLE_403
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2,SYSCLK_FREQ_192MHz
  c include: ..\SYSTEM;..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\APP_LED4_TOGGLE
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s startup_at32f413rx_hd.s startup_at32f415rct7.s startup_at32f403avgt7.s startup_at32f407vgt7.s startup_at32f421c8t7.s
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_gpio_ex.c misc.c
  group SYSTEM
    ../SYSTEM/: iap.c led.c usart.c
target 413_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_LED4_TOGGLE_413
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0,SYSCLK_FREQ_192MHz
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 415_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: APP_LED4_TOGGLE_415
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1_0,SYSCLK_FREQ_144MHz
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target 403A_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: as above
  output: APP_LED4_TOGGLE_403A
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1_0,SYSCLK_FREQ_240MHz
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target 407_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: as above
  output: APP_LED4_TOGGLE_407
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1_0,SYSCLK_FREQ_240MHz
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target 421_Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: APP_LED4_TOGGLE_421
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0,SYSCLK_FREQ_120MHz
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
