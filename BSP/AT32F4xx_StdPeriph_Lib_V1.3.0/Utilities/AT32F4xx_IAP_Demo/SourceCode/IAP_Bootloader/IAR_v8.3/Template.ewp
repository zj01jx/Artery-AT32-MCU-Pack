# IAR project Template.ewp, settings and files
configuration 403_Project (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ZG ArteryTek AT32F403ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403Zx_XL; USE_STDPERIPH_DRIVER; AT_START_F403_V1_2; SYSCLK_FREQ_192MHz
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..; ..\SYSTEM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAP_403.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: AT32F403xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 413_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RC ArteryTek AT32F413RC
  ICCARM.CCDefines: AT32F413Rx_HD; USE_STDPERIPH_DRIVER; AT_START_F413_V1_0; SYSCLK_FREQ_192MHz
  OBJCOPY.OOCOutputFile: IAP_413.bin
  ILINK.IlinkIcfFile: AT32F413xC.icf
configuration 415_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F415RCT7 ArteryTek AT32F415RCT7
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; USE_STDPERIPH_DRIVER; AT_START_F415_V1_0; SYSCLK_FREQ_144MHz
  OBJCOPY.OOCOutputFile: IAP_415.bin
  ILINK.IlinkIcfFile: AT32F415xC.icf
configuration 403A_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F403AVGT7 ArteryTek AT32F403AVGT7
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1_0; SYSCLK_FREQ_240MHz
  OBJCOPY.OOCOutputFile: IAP_403A.bin
  ILINK.IlinkIcfFile: AT32F403AxG.icf
configuration 407_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F407VGT7 ArteryTek AT32F407VGT7
  ICCARM.CCDefines: AT32F407VGT7; USE_STDPERIPH_DRIVER; AT_START_F407_V1_0; SYSCLK_FREQ_240MHz
  OBJCOPY.OOCOutputFile: IAP_407.bin
  ILINK.IlinkIcfFile: AT32F407xG.icf
configuration 421_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1_0; SYSCLK_FREQ_120MHz
  OBJCOPY.OOCOutputFile: IAP_421.bin
  ILINK.IlinkIcfFile: AT32F421x8.icf
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c misc.c
  group CMSIS
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f403avgt7.s startup_at32f403zx_xl.s startup_at32f407vgt7.s startup_at32f413rx_hd.s startup_at32f415rct7.s startup_at32f421c8t7.s
    ../: system_at32f4xx.c
  group SYSTEM
    ../SYSTEM/: flash.c iap.c led.c sys.c usart.c
  group USER
    ../: at32f4xx_it.c main.c
