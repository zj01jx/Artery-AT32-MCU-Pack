# Keil uVision project Gen_Ramdom_Number.uvprojx, settings and files
target AT_START_F403 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gen_Ramdom_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL,USE_STDPERIPH_DRIVER,AT_START_F403_V1_2
  c include: ..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Project\AT32_Board;..\..\AT32F4xx_Gen_Random_Number_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c random.c
  group BSP
    ../../../Project/AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s startup_at32f413rx_hd.s startup_at32f415rct7.s startup_at32f403avgt7.s startup_at32f407vgt7.s startup_at32f421c8t7.s
  group AT32Periph
    ../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: misc.c at32f4xx_usart.c at32f4xx_rtc.c at32f4xx_rcc.c at32f4xx_gpio.c at32f4xx_bkp.c at32f4xx_pwr.c at32f4xx_ertc.c at32f4xx_gpio_ex.c
  group README
    ../: readme.txt
target AT_START_F413 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gen_Random_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0
  c include: ..\..\Printf;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\Project\AT32_Board;..\..\AT32F4xx_Gen_Random_Number_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target AT_START_F415 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Gen_Random_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target AT_START_F403A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gen_Random_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F403A_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target AT_START_F407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: as above
  output: Gen_Random_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F407_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target AT_START_F421 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Gen_Random_Number
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F421_V1_0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
