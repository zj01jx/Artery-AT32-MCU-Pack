# Keil uVision project Project_L1.uvprojx, settings and files
target End-User-Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Project_L1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1_0,ARM_MATH_CM4
  c include: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\Project\AT32_Board;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\End-User-Code.sct
  link misc: --keep slib_used_c_lib.o
  group User
    ../src/: main.c at32f4xx_it.c arm_fir_data.c math_helper.c
  group Drivers/CMSIS
    ../src/: system_at32f4xx.c
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415rct7.s
  group Drivers/BSP
    ../../../../Project/AT32_Board/: at32_board.c
  group Drivers/AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_usart.c misc.c
  group FIR_Filter
    ./: fir_filter_symbol.txt slib_used_c_lib.s
  group Doc
    ../: readme.txt
