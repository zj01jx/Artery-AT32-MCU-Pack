# IAR project Project_L0.ewp, settings and files
configuration Release (ARM)
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration SLIB-IP-Code-XO (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F421C8T7 ArteryTek AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1_0; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Project\AT32_Board; ..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..\inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: Project_L0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: Project_L0.out
  ILINK.IlinkIcfFile: SLIB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_dbgmcu.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_syscfg.c at32f4xx_usart.c misc.c
  group Drivers/BSP
    ../../../../Project/AT32_Board/: at32_board.c
  group Drivers/CMSIS
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f421c8t7.s
    ../src/: system_at32f4xx.c
  group FIR_Filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group User
    ../src/: arm_fir_data.c at32f4xx_it.c main.c math_helper.c
