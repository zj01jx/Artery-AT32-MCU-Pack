# Keil uVision project Project_L0.uvprojx, settings and files
target SLIB-IP-CODE-XO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Project_L0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1_0,ARM_MATH_CM4
  c include: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\Project\AT32_Board;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\SLIB-w-XO.sct
  link misc: --symdefs=fir_filter_symbol.txt
  group User
    ../src/: main.c at32f4xx_it.c arm_fir_data.c math_helper.c
  group Drivers/CMSIS
    ../src/: system_at32f4xx.c
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
  group Drivers/BSP
    ../../../../Project/AT32_Board/: at32_board.c
  group Drivers/AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_syscfg.c at32f4xx_usart.c misc.c
  group FIR_Filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_filter.c fir_coefficient.c
