# Keil uVision project VirtualMassStrorage_IAP_Demo.uvprojx, settings and files
target MassStorage_IAP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.3
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: MS_IAP +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\..\..\AT32_Board;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_OTG_Driver\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_Device_Library\Core\inc;..\..\..\..\..\..\Middlewares\AT32_USB_OTG_Library\USB_Device_Library\Class\msc\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../src/: at32f4xx_it.c main.c usbd_desc.c usbd_usr.c usb_bsp.c usbd_storage_msd.c FAT16.c flash_if.c
  group CMSIS
    ../src/: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415rct7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_dma.c at32f4xx_exti.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_sdio.c at32f4xx_tim.c at32f4xx_usart.c misc.c at32f4xx_flash.c at32f4xx_crc.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group OTG_USB_Device_MSC
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group OTG_USB_Device_Library
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group OTG_USB_Driver
    ../../../../../../Middlewares/AT32_USB_OTG_Library/USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group README
    ../: readme.txt
