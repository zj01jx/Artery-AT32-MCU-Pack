# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target AT_START_F403 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F403Zx_XL
  c include: ..\..\..\..\..\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\CM4\CoreSupport;..\..\..\..\CM4\DeviceSupport;..\..\arm_class_marks_example;..\..\..\..\..\..\Project\Templates
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c math_helper.c
  group CMSIS
    ../../../../CM4/DeviceSupport/: system_at32f4xx.c
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib arm_cortexM4l_math.lib
    ../../../../CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s startup_at32f413rx_hd.s startup_at32f415rct7.s startup_at32f403avgt7.s startup_at32f407vgt7.s startup_at32f421c8t7.s
  group AT32Periph
    ../../../../../AT32F4xx_StdPeriph_Driver/src/: at32f4xx_rcc.c
  group DOC
    ./: Abstract.txt
target AT_START_F413 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F413Rx_HD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target AT_START_F415 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F415RCT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F415RCT7
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target AT_START_F403A (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: as above
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F403AVGT7
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target AT_START_F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: as above
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F407VGT7
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
target AT_START_F421 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION,ARM_MATH_CM4,AT32F421C8T7
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
